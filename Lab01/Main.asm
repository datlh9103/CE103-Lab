org 00h
MAIN:
	CALL DELAYCT1
	CALL CT2
	CALL DELAYCT3
	JMP MAIN
DELAYCT1:
MOV R3, #20
MOV A, 11111111B
	CT1:
		MOV P0, A
		MOV P1, A
		MOV P2, A
		MOV P3, A
		CPL A
		CALL DELAY
DJNZ R3, CT1
RET
CT2:
	MOV A, #11111111B
	CLR C
	FOR0:
		RLC A
		MOV P0, A
		MOV P3, A
		CALL DELAY
		CJNE A, #00000000B, FOR0
		MOV A, #11111111B
	FOR1:
		RLC A
		MOV P1, A
		MOV P2, A 
		CALL DELAY
		CJNE A, #00000000B, FOR1
	FOR2:
		RLC A
		MOV P0, A
		MOV P3, A
		CALL DELAY
		CJNE A, #11111111B, FOR2
		MOV A, #00000000B
	FOR3:
		RLC A
		MOV P1, A
		MOV P2, A 
		CALL DELAY
		CJNE A, #11111111B, FOR3
		MOV A, #00000000B
RET
DELAYCT3:
	MOV R3, #20
	MOV A, #01010101B
CT3:
	MOV P0, A
	MOV P1, A
	RR A
	MOV P2, A
	MOV P3, A
	CALL DELAY
	DJNZ R3, CT3
RET
DELAY:
	MOV R0, #5
LOOP1:
	MOV R1, #125
LOOP2:
	MOV R2, #250
	DJNZ R2, $
	DJNZ R1, LOOP2
	DJNZ R0, LOOP1
RET
END