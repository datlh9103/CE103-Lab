# Keil uVision project LeHuuDat-21520697-Lab2-Delay.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LeHuuDat-21520697-Lab2-Delay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Lab2-21520697-LeHuuDat-Delay.asm
