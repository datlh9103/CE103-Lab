// 1 TAT
// 0 SANG
//R0 GIO
//R1 PHUT
//R2 GIAY
ORG 00H
MOV R0, #23
MOV R1, #58
MOV R2, #0
MAIN:
	CALL CLOCK
	JMP MAIN
CLOCK:
	CALL HIENTHI
	INC R2
	CJNE R2, #60, CLOCK
	INC R1
	MOV R2, #0
	CJNE R1, #60, CLOCK
	INC R0
	MOV R1, #0
	CJNE R0, #24, CLOCK
	MOV R0, #0
	RET
HIENTHI:
	MOV DPTR, #MALED
	MOV R3, #25
	HT1:
		MOV A, R0
		MOV B, #10
		DIV AB
		MOVC A, @A + DPTR
		MOV P0, A
		SETB P3.0
		CALL DELAY
		CLR P3.0
		MOV A, B
		MOVC A, @A + DPTR
		MOV P0, A
		CLR P0.7
		SETB P3.1
		CALL DELAY
		CLR P3.1
		SETB P0.7
		MOV A, R1
		MOV B, #10
		DIV AB
		MOVC A, @A + DPTR
		MOV P0, A
		SETB P3.2
		CALL DELAY
		CLR P3.2
		MOV A, B
		MOVC A, @A + DPTR
		MOV P0, A
		SETB P3.3
		CALL DELAY
		CLR P3.3
		DJNZ R3, HT1
	RET
DELAY:
	MOV R4, #20
LOOP1:
	MOV R5, #250
	DJNZ R5, $
	DJNZ R4, LOOP1
RET
MALED: DB 0XC0, 0XF9, 0XA4, 0XB0, 0X99, 0X92, 0X82, 0XF8, 0X80, 0X90
	END