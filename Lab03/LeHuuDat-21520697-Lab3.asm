ORG 0000H
	SJMP MAIN
ORG 0003H
	SJMP BUTTON_A
ORG 0013H
	SJMP BUTTON_B
MAIN:
	MOV R0, #0
	MOV R1, #0
	MOV IE, #85H
	CALL CLOCK
	JMP MAIN
CLOCK:
	CALL HIENTHI
	JB P3.4, NEXT
	JNB P3.4, $
	INC R0
NEXT:
	JB P3.5, NEXT1
	JNB P3.5, $
	DEC R0
NEXT1:
	INC R1
	CJNE R1, #100, CLOCK
	INC R0
	MOV R1, #0
	CJNE R0, #100, CLOCK
	MOV R0, #0
	RET
HIENTHI:
	MOV DPTR, #MALED
	MOV A, R0
	MOV B, #10
	DIV AB
	MOVC A, @A + DPTR
	MOV P0, A
	SETB P2.0
	CALL DELAY
	CLR P2.0
	MOV A, B
	MOVC A, @A + DPTR
	MOV P0, A
	SETB P2.1
	CALL DELAY
	CLR P2.1
		
	MOV A, R1
	MOV B, #10
	DIV AB
	MOVC A, @A + DPTR
	MOV P0, A
	SETB P2.2
	CALL DELAY
	CLR P2.2
	MOV A, B
	MOVC A, @A + DPTR
	MOV P0, A
	SETB P2.3
	CALL DELAY
	CLR P2.3
	RET
BUTTON_A:
	JNB P3.2, $
LOOP:
	CALL HIENTHI
	JB P3.2, LOOP
	JNB P3.2, $ 
	RETI
BUTTON_B:
	MOV R0, #0
	MOV R1, #0
	RETI
DELAY:
	MOV R2, #5
DELAY1:
	MOV R3, #246
	DJNZ R3, $
	DJNZ R2, DELAY1
	RET
MALED: DB 0XC0, 0XF9, 0XA4, 0XB0, 0X99, 0X92, 0X82, 0XF8, 0X80, 0X90
END